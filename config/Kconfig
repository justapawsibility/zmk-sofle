## config/dts/bindings/behaviors/zmk,behavior-split-battery-type.yaml
```yaml
description: Split battery typing behavior

compatible: "zmk,behavior-split-battery-type"

include: zero_param.yaml
```
